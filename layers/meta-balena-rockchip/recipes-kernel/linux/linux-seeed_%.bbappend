FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://balena-container.cfg"
